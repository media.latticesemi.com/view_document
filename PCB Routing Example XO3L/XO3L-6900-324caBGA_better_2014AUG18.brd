# Allegro board XO3L-6900-324caBGA_better_2014AUG18.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PT27A: length 10.3
  TOP w0.102: BGA.C12 v1(21.92,25.92)
  L3_SIGNAL w0.102: 22.32,35.47 22.32,26.32 21.92,25.92 v1(21.92,25.92)
PT27B: length 10.2
  TOP w0.102: BGA.B13 v1(22.72,25.92)
  L3_SIGNAL w0.102: v1(22.72,25.92) 22.72,26.16 22.57,26.31 22.57,35.47
PT27C: length 12
  TOP w0.102: BGA.D11 v1(21.12,24.32)
  BOTTOM w0.102: 21.81,35.45 21.81,27.24 21.52,26.95 21.52,26.72 BGA.D11 v1(21.12,24.32)
PT27D: length 11.2
  TOP w0.102: BGA.D12 v1(21.92,25.12)
  BOTTOM w0.102: 22.01,35.45 22.01,27.19 22.32,26.89 22.32,25.52 v1(21.92,25.12)
PT28A: length 8.5
  TOP w0.102: BGA.A13 23.42,27.42 23.42,35.45
PT28B: length 8.5
  TOP w0.102: BGA.A14 23.62,27.42 23.62,35.45
PT32A: length 15.1
  TOP w0.102: BGA.F11 v1(21.12,22.72)
  BOTTOM w0.102: v1(21.12,22.72) BGA.F11 21.52,23.69 21.75,23.92 22.09,23.92 22.32,24.15 22.32,24.49 22.55,24.72 22.89,24.72 23.12,24.95 23.12,25.29 23.35,25.52 23.69,25.52 23.92,25.75 23.92,26.09 23.92,26.27 23.67,26.52 23.67,35.45
PT32B: length 11.2
  TOP w0.102: BGA.C13 v1(22.72,25.12)
  BOTTOM w0.102: v1(22.72,25.12) 22.72,25.24 23.12,25.64 23.12,26.22 23.46,26.57 23.46,35.45
PT33A: length 10.2
  TOP w0.102: BGA.B14 v1(23.52,25.92)
  L3_SIGNAL w0.102: v1(23.52,25.92) 23.81,26.21 23.81,35.47
PT33B: length 10.2
  TOP w0.102: BGA.B15 v1(24.32,25.92)
  L3_SIGNAL w0.102: v1(24.32,25.92) 24.01,26.23 24.01,35.47
PT33C: length 12
  TOP w0.102: BGA.E12 v1(21.92,24.32)
  L4_SIGNAL w0.102: v1(21.92,24.32) 22.32,24.72 22.32,27.07 22.02,27.37 22.02,35.46
PT33D: length 12.8
  TOP w0.102: BGA.F12 v1(21.92,23.52)
  L4_SIGNAL w0.102: 21.82,35.46 21.82,27.38 21.52,27.08 21.52,23.92 v1(21.92,23.52)
PT34A: length 12
  TOP w0.102: BGA.C14 v1(23.52,25.12)
  L3_SIGNAL w0.102: 25.22,35.47 25.22,26.19 24.56,25.52 BGA.C14 v1(23.52,25.12)
PT34B: length 11.5
  TOP w0.102: BGA.C15 v1(24.32,25.12)
  L3_SIGNAL w0.102: v1(24.32,25.12) 24.47,25.27 24.59,25.27 25.43,26.1 25.43,35.47
PT34C: length 12
  TOP w0.102: BGA.D13 v1(22.72,24.32)
  L4_SIGNAL w0.102: v1(22.72,24.32) BGA.D13 23.12,26.4 23.42,26.7 23.42,35.45
PT34D: length 13.5
  TOP w0.102: BGA.E13 v1(22.72,23.52)
  L4_SIGNAL w0.102: 23.62,35.45 23.62,26.72 23.92,26.42 23.92,24.02 23.82,23.92 23.43,23.92 BGA.E13 v1(22.72,23.52)
PT35A: length 8.5
  TOP w0.102: 25.03,35.46 25.03,27.43 BGA.A15
PT35B: length 8.5
  TOP w0.102: 25.23,35.46 25.23,27.41 BGA.A16
PT35C: length 12.5
  TOP w0.102: BGA.D14 v1(23.52,24.32)
  BOTTOM w0.102: 24.93,35.45 24.93,25.92 24.52,25.52 24.15,25.52 23.92,25.29 23.92,25.28 BGA.D14 v1(23.52,24.32)
PT35D: length 12
  TOP w0.102: BGA.D15 v1(24.32,24.32)
  BOTTOM w0.102: 25.13,35.45 25.13,25.77 24.72,25.36 24.72,24.92 24.32,24.52 v1(24.32,24.32)
PT36A: length 9.3
  TOP w0.102: BGA.B16 25.92,26.72 25.92,35.46
PT36B: length 8.4
  TOP w0.102: 26.12,35.46 26.12,27.32 BGA.A17
PT36C: length 11.8
  TOP w0.102: BGA.C16 v1(25.12,25.12)
  L3_SIGNAL w0.102: 35.97,26.07 26.79,26.07 26.72,26.01 26.72,26.01 26.08,25.37 25.37,25.37 v1(25.12,25.12)
PT36D: length 14.4
  TOP w0.102: BGA.E14 v1(23.52,23.52)
  L3_SIGNAL w0.102: 35.97,25.87 26.87,25.87 26.07,25.07 25.75,25.07 25.4,24.72 24.07,24.72 23.92,24.57 BGA.E14 v1(23.52,23.52)

## Copper pours and planes (outline as drawn)
GND on L2_GND: 1,1 1,39.64 39.64,39.64 39.64,1
VCC on L5_PWR: 34.51,35.21 34.51,5.41 5.92,5.41 5.92,35.21

## Text on the board
User.Comments: RP | RCI | 08/18/14 | 18/18/14 | DWG NO: | XO3L-69E-400caBGA | REVISION | 1.0 | SHEET | 1 | OF | XO3L-69E-400CABGA PCB BREAKOUT | LATTICE SEMICONDUCTOR CORPORATION
Ref Des/Silkscreen Top: PCB BREAKOUT | XO3L-69E-324CABGA | SEMICONDUCTOR | LATTICE | A | B | C | D | E | F | G | H | J | K | L | M | N | P | R | T | U | V | 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9 | 10 | 11 | 12 | 13 | 14 | 15 | 16 | 17 | 18
PAGE_OUTLINE: 1 | INITIAL RELEASE | MM/DD/YYYY | XXXX XXXXX | SPECIAL INSTRUCTIONS: | 1/2 CU OZ FOR INTERNAL AND EXTERNAL LAYERS | MIN BOARD THICKNESS IS 62MILS. | DESIGNED BY: | APPROVED BY: | SIGNATURES         DATE | REV | DESCRIPTION | ESCAPE VIA DRILL | TRACE WIDTH/SPACE | ESCAPE VIA PAD | ARRAY SIZE | BGA LAND OPENING | BGA LAND PAD | PACKAGE SIZE | PITCH | SIGNAL         (L4) | SIGNAL         (L3) | GND     PLANE  (L2) | POWER   PLANE  (L5) | PRIMARY SIDE   (L1) | SECONDARY SIDE (L6) | SECONDARY SILKSCREEN | SECONDARY SOLDERMASK | PRIMARY SOLDERMASK | PRIMARY SILKSCREEN | 0.8 | 18 X 18 | 15 X 15 | 0.3556 | 0.4572 | 0.254 | 0.10/0.10 | MM | DATE | 708.66 X 708.66 | 590.55 X 590.55 | 31.5 | 4/4 | 18 | 14 | 10 | MILS | APPROVED | PCB BREAKOUT DETAILS | 6 LAYER STACKUP | REVISION
BODY_CENTER: FIGURE | SIZE | 10.0 | ALL UNITS ARE IN MILS | SIZE MM | 0.254 | PLATED | QTY | 83 | DRILL CHART: TOP to L4_SIGNAL
PLACE_BOUND_TOP: FIGURE | SIZE | 10.0 | ALL UNITS ARE IN MILS | SIZE MM | 0.254 | PLATED | QTY | 116 | DRILL CHART: TOP to L3_SIGNAL
DISPLAY_TOP: FIGURE | SIZE | 10.0 | ALL UNITS ARE IN MILS | SIZE MM | 0.254 | PLATED | QTY | 50 | DRILL CHART: TOP to BOTTOM
